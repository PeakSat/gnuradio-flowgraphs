options:
  parameters:
    generate_options: qt_gui
    id: fsk
    output_language: python
    title: SatNOGS-COMMS FSK transceiver
  states: {}

blocks:
- name: deviation
  id: variable
  parameters:
    comment: The FSK frequency deviation
    value: 25e3
  states: {}
- name: gaussian_taps
  id: variable
  parameters:
    value: filter.firdes.gaussian(1.0, sps_tx, 1.0, 4*sps_tx)
  states: {}
- name: interp_taps
  id: variable
  parameters:
    value: numpy.convolve(numpy.array(gaussian_taps), numpy.array(sq_wave))
  states: {}
- name: modulation_index
  id: variable
  parameters:
    value: deviation / (baudrate / 2.0)
  states: {}
- name: sq_wave
  id: variable
  parameters:
    value: (1.0, ) * sps_tx
  states: {}
- name: variable_ieee802_15_4_encoder_0
  id: variable_ieee802_15_4_encoder
  parameters:
    crc_type: CRC32_C
    custom_crc: satnogs.crc.crc16(0x1021, 0xFFFF, 0xFFFF, True, True)
    preamble: '0b01010101'
    preamble_len: '32'
    rs: 'False'
    sync_word: '[0x1A, 0xCF, 0xFC, 0x1D]'
    var_len: 'False'
    whitening: satnogs.whitening.make_ccsds(True)
  states: {}
- name: variable_ieee802_15_4_variant_decoder_0
  id: variable_ieee802_15_4_variant_decoder
  parameters:
    crc_type: CRC32_C
    custom_crc: satnogs.crc.crc16(0x1021, 0xFFFF, 0xFFFF, True, True)
    drop_invalid: 'True'
    frame_len: 196-4
    preamble: '[0b01010101]*28'
    preamble_thrsh: '5'
    rs: 'False'
    sync_thrsh: '4'
    sync_word: '[0x1A, 0xCF, 0xFC, 0x1D]'
    var_len: 'False'
    whitening: satnogs.whitening.make_ccsds(True)
  states: {}
- name: analog_frequency_modulator_fc_0
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: (math.pi*modulation_index) / sps_tx - (((math.pi*modulation_index) / sps_tx) * 0.1)
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: (2*math.pi*baudrate)/(sps_rx * baudrate)
  states: {}
- name: baudrate
  id: parameter
  parameters:
    type: eng_float
    value: 50e3
  states: {}
- name: bladeRF_sink_0
  id: bladeRF_sink
  parameters:
    bias_tee0: 'False'
    bias_tee1: 'False'
    buffers: '1024'
    buflen: '4096'
    bw: '200000'
    dac: '10000'
    dc_calibration: LPF_TUNING
    device_id: '0'
    feature: default
    fpga_image: ''
    fpga_reload: 'False'
    freq: tx_freq
    gain0: '0'
    gain1: '10'
    if_gain0: '20'
    if_gain1: '20'
    in_clk: ONBOARD
    lpf_mode: disabled
    metadata: 'False'
    nchan: '1'
    out_clk: 'False'
    ref_clk: 10e6
    sample_format: 16bit
    sample_rate: samp_rate
    sampling: internal
    show_pmic: 'False'
    smb: 38.4e6
    tamer: internal
    trigger0: 'False'
    trigger1: 'False'
    trigger_role0: master
    trigger_role1: master
    trigger_signal0: J51_1
    trigger_signal1: J51_1
    use_dac: 'False'
    use_ref_clk: 'True'
    verbosity: verbose
    xb200: none
  states: {state: disabled}
- name: bladeRF_source_0
  id: bladeRF_source
  parameters:
    bias_tee0: 'False'
    bias_tee1: 'False'
    buffers: '512'
    buflen: '4096'
    bw: '200000'
    dac: '10000'
    dc_calibration: LPF_TUNING
    dc_offset_mode0: '0'
    dc_offset_mode1: '0'
    device_id: '0'
    feature: default
    fpga_image: ''
    fpga_reload: 'False'
    freq: rx_freq
    gain0: '10'
    gain1: '10'
    gain_mode0: 'False'
    gain_mode1: 'False'
    if_gain0: '20'
    if_gain1: '20'
    in_clk: ONBOARD
    iq_balance_mode0: '0'
    iq_balance_mode1: '0'
    lpf_mode: disabled
    metadata: 'False'
    nchan: '1'
    out_clk: 'False'
    ref_clk: 10e6
    sample_format: 16bit
    sample_rate: samp_rate
    sampling: internal
    show_pmic: 'False'
    smb: 38.4e6
    tamer: internal
    trigger0: 'False'
    trigger1: 'False'
    trigger_role0: master
    trigger_role1: master
    trigger_signal0: J51_1
    trigger_signal1: J51_1
    use_dac: 'False'
    use_ref_clk: 'False'
    verbosity: verbose
    xb200: none
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/maestroque/repos/gnuradio-flowgraphs/fsk_tx_cap.bin
    type: complex
  states: {state: disabled}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_debug_0_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_packed_to_unpacked_xx_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_tagged_stream_align_0
  id: blocks_tagged_stream_align
  parameters:
    lengthtagname: packet_len
    type: complex
  states: {}
- name: blocks_tagged_stream_multiply_length_0_0
  id: blocks_tagged_stream_multiply_length
  parameters:
    c: (samp_rate/(baudrate*sps_tx))
    lengthtagname: packet_len
    type: complex
  states: {}
- name: blocks_tagged_stream_multiply_length_0_0_0
  id: blocks_tagged_stream_multiply_length
  parameters:
    c: '(sps_tx * 8) '
    comment: Length tag should be fixed for the burst tagger to work properly
    lengthtagname: packet_len
    type: complex
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_burst_shaper_xx_0
  id: digital_burst_shaper_xx
  parameters:
    insert_phasing: 'False'
    length_tag_name: packet_len
    post_padding: '4000'
    pre_padding: '2000'
    type: complex
    window: ([])
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: float
    symbol_table: '[-1, 1]'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: 1/math.sqrt(2)
    loop_bw: 2*math.pi/200
    max_dev: '0.1'
    nfilters: '128'
    osps: '1'
    resamp_type: digital.IR_PFB_NO_MF
    sps: sps_rx
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: ff
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    interp: sps_tx
    taps: interp_taps
    type: fff
  states: {}
- name: pdu_pdu_to_stream_x_0
  id: pdu_pdu_to_stream_x
  parameters:
    early_behavior: pdu.EARLY_BURST_APPEND
    type: complex
  states: {state: disabled}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_tags_to_pdu_x_0
  id: pdu_tags_to_pdu_x
  parameters:
    end_tag: tx_eob
    start_tag: tx_sob
    type: c
  states: {state: disabled}
- name: pfb_arb_resampler_xxx_0
  id: pfb_arb_resampler_xxx
  parameters:
    atten: '100'
    nfilts: '32'
    rrate: ' (sps_rx * baudrate)/samp_rate'
    type: ccf
  states: {}
- name: pfb_arb_resampler_xxx_0_0_0
  id: pfb_arb_resampler_xxx
  parameters:
    atten: '100'
    nfilts: '32'
    rrate: samp_rate/(baudrate*sps_tx)
    type: ccf
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    ctrlpanel: 'True'
    fc: rx_freq
    fftsize: '8192'
    grid: 'True'
    name: '"RX"'
    type: complex
    update_time: '0.01'
    ymax: '0'
    ymin: '-120'
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    ctrlpanel: 'True'
    fc: tx_freq
    fftsize: '8192'
    grid: 'True'
    name: '"TX"'
    type: complex
    update_time: '0.01'
    ymax: '0'
    ymin: '-120'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: '"RX"'
    size: 1024 * 8
    srate: samp_rate
    type: complex
    update_time: '0.01'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    name: '"RX Timeseries"'
    size: '1024'
    srate: baudrate
    type: float
    update_time: '0.01'
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    name: '"TX Timeseries"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_1_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    srate: samp_rate
    type: msg_float
  states: {state: disabled}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: rx_freq
  id: parameter
  parameters:
    type: eng_float
    value: 400.5e6
  states: {}
- name: rx_gain
  id: parameter
  parameters:
    type: eng_float
    value: '55.0'
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    type: eng_float
    value: 2e6
  states: {}
- name: satnogs_crc_async_0
  id: satnogs_crc_async
  parameters:
    check: 'False'
    comment: |-
      This block adds some extra bytes at the 
      end of the frame that have no actual
      contribution to the original frame. They act
      as a trailing burst shaping. We have identified that
      there is a problem at the last byte received by the
      SatNOGS-COMMS and it is related to this TX chain.
      Burst shaper seems that does not solve the issue
      so probably the problem is earlier at the TX chain.
    custom_crc: satnogs.crc.crc16(0x1021, 0xFFFF, 0xFFFF, True, True)
    nbo: 'False'
    type: CRC32_C
  states: {}
- name: satnogs_frame_decoder_0
  id: satnogs_frame_decoder
  parameters:
    decoder_object: variable_ieee802_15_4_variant_decoder_0
    itype: byte
    vlen: '1'
  states: {}
- name: satnogs_frame_encoder_0
  id: satnogs_frame_encoder
  parameters:
    encoder_object: variable_ieee802_15_4_encoder_0
  states: {}
- name: soapy_bladerf_sink_0
  id: soapy_bladerf_sink
  parameters:
    center_freq: tx_freq
    gain: '50'
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}
- name: soapy_bladerf_source_0
  id: soapy_bladerf_source
  parameters:
    center_freq: rx_freq
    gain: '0'
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}
- name: soapy_limesdr_source_0
  id: soapy_limesdr_source
  parameters:
    center_freq: rx_freq
    gain: rx_gain
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}
- name: soapy_sink_0
  id: soapy_sink
  parameters:
    center_freq0: tx_freq
    devname: bladerf
    length_tag_name: packet_len
    manual_gain0: 'False'
    overall_gain0: '20'
    samp_rate: samp_rate
    txvga1_gain: '10.25'
    type: fc32
  states: {state: disabled}
- name: sps_rx
  id: parameter
  parameters:
    type: intx
    value: '4'
  states: {}
- name: sps_tx
  id: parameter
  parameters:
    type: intx
    value: '16'
  states: {}
- name: tx_freq
  id: parameter
  parameters:
    type: eng_float
    value: 401.5e6
  states: {}
- name: tx_gain
  id: parameter
  parameters:
    type: eng_float
    value: '45'
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: tx_freq
    gain0: tx_gain
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    center_freq0: rx_freq
    gain0: rx_gain
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: SDR
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: SDR
  states: {}
- name: zeromq_pub_msg_sink_1
  id: zeromq_pub_msg_sink
  parameters:
    address: zmq_pub_uri
    timeout: '100'
  states: {}
- name: zeromq_sub_msg_source_0
  id: zeromq_sub_msg_source
  parameters:
    address: zmq_sub_uri
    timeout: '100'
  states: {}
- name: zmq_pub_uri
  id: parameter
  parameters:
    comment: URI of the ZMQ PUB, broadcasting received frames
    type: str
    value: tcp://127.0.0.1:55000
  states: {}
- name: zmq_sub_uri
  id: parameter
  parameters:
    comment: URI of the ZMQ SUB, fetching frames for transmission
    type: str
    value: tcp://127.0.0.1:55001
  states: {}

connections:
- [analog_frequency_modulator_fc_0, '0', blocks_tagged_stream_multiply_length_0_0_0, '0']
- [analog_quadrature_demod_cf_0, '0', digital_symbol_sync_xx_0, '0']
- [bladeRF_source_0, '0', virtual_sink_0, '0']
- [blocks_packed_to_unpacked_xx_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [blocks_tagged_stream_align_0, '0', bladeRF_sink_0, '0']
- [blocks_tagged_stream_align_0, '0', blocks_file_sink_0, '0']
- [blocks_tagged_stream_align_0, '0', pdu_tags_to_pdu_x_0, '0']
- [blocks_tagged_stream_align_0, '0', qtgui_freq_sink_x_0_0, '0']
- [blocks_tagged_stream_align_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_tagged_stream_align_0, '0', soapy_bladerf_sink_0, '0']
- [blocks_tagged_stream_align_0, '0', soapy_sink_0, '0']
- [blocks_tagged_stream_align_0, '0', uhd_usrp_sink_0, '0']
- [blocks_tagged_stream_multiply_length_0_0, '0', blocks_tagged_stream_align_0, '0']
- [blocks_tagged_stream_multiply_length_0_0, '0', soapy_sink_0, '0']
- [blocks_tagged_stream_multiply_length_0_0_0, '0', digital_burst_shaper_xx_0, '0']
- [digital_binary_slicer_fb_0, '0', satnogs_frame_decoder_0, '0']
- [digital_burst_shaper_xx_0, '0', pfb_arb_resampler_xxx_0_0_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', interp_fir_filter_xxx_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_binary_slicer_fb_0, '0']
- [digital_symbol_sync_xx_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [interp_fir_filter_xxx_0, '0', analog_frequency_modulator_fc_0, '0']
- [interp_fir_filter_xxx_0, '0', qtgui_time_sink_x_2, '0']
- [pdu_pdu_to_stream_x_0, '0', soapy_bladerf_sink_0, '0']
- [pdu_pdu_to_tagged_stream_0, '0', blocks_packed_to_unpacked_xx_0, '0']
- [pdu_tags_to_pdu_x_0, pdus, pdu_pdu_to_stream_x_0, pdus]
- [pdu_tags_to_pdu_x_0, pdus, qtgui_time_sink_x_1_0, in]
- [pfb_arb_resampler_xxx_0, '0', analog_quadrature_demod_cf_0, '0']
- [pfb_arb_resampler_xxx_0_0_0, '0', blocks_tagged_stream_multiply_length_0_0, '0']
- [satnogs_crc_async_0, out, pdu_pdu_to_tagged_stream_0, pdus]
- [satnogs_frame_decoder_0, out, blocks_message_debug_0, print]
- [satnogs_frame_decoder_0, out, zeromq_pub_msg_sink_1, in]
- [satnogs_frame_encoder_0, pdu, blocks_message_debug_0_0, print]
- [satnogs_frame_encoder_0, pdu, satnogs_crc_async_0, in]
- [soapy_bladerf_source_0, '0', virtual_sink_0, '0']
- [soapy_limesdr_source_0, '0', virtual_sink_0, '0']
- [uhd_usrp_source_0, '0', virtual_sink_0, '0']
- [virtual_source_0, '0', pfb_arb_resampler_xxx_0, '0']
- [virtual_source_0, '0', qtgui_freq_sink_x_0, '0']
- [virtual_source_0, '0', qtgui_time_sink_x_0, '0']
- [zeromq_sub_msg_source_0, out, satnogs_frame_encoder_0, pdu]

metadata:
  file_format: 1
  grc_version: 3.10.9.2
