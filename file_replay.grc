options:
  parameters:
    generate_options: qt_gui
    id: file_replay
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/kikas/repos/gnuradio-flowgraphs/fsk_tx_cap.bin
    repeat: 'True'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    type: eng_float
    value: 2e6
  states: {}
- name: soapy_bladerf_sink_0
  id: soapy_bladerf_sink
  parameters:
    center_freq: tx_freq
    gain: tx_gain
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}
- name: tx_freq
  id: parameter
  parameters:
    type: eng_float
    value: 401.5e6
  states: {}
- name: tx_gain
  id: parameter
  parameters:
    type: eng_float
    value: '45'
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: tx_freq
    gain0: '0'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_file_source_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_file_source_0, '0', soapy_bladerf_sink_0, '0']
- [blocks_file_source_0, '0', uhd_usrp_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
