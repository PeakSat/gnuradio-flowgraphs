options:
  parameters:
    generate_options: qt_gui
    id: test
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: deviation
  id: variable
  parameters:
    comment: The FSK frequency deviation
    value: 25e3
  states: {}
- name: gaussian_taps
  id: variable
  parameters:
    value: filter.firdes.gaussian(1.0, sps_tx, 1.0, 4*sps_tx)
  states: {}
- name: interp_taps
  id: variable
  parameters:
    value: numpy.convolve(numpy.array(gaussian_taps), numpy.array(sq_wave))
  states: {}
- name: modulation_index
  id: variable
  parameters:
    value: deviation / (baudrate / 2.0)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: sq_wave
  id: variable
  parameters:
    value: (1.0, ) * sps_tx
  states: {}
- name: variable_ieee802_15_4_encoder_0
  id: variable_ieee802_15_4_encoder
  parameters:
    crc_type: NONE
    custom_crc: satnogs.crc.crc16(0x1021, 0xFFFF, 0xFFFF, True, True)
    preamble: '0b00001000'
    preamble_len: '12'
    rs: 'False'
    sync_word: '[0x1A, 0xCF, 0xFC, 0x1D]'
    var_len: 'False'
    whitening: satnogs.whitening.make_none()
  states: {}
- name: variable_ieee802_15_4_variant_decoder_0
  id: variable_ieee802_15_4_variant_decoder
  parameters:
    crc_type: CRC32_C
    custom_crc: satnogs.crc.crc16(0x1021, 0xFFFF, 0xFFFF, True, True)
    drop_invalid: 'True'
    frame_len: 448-4
    preamble: '[0b01010101]*12'
    preamble_thrsh: '0'
    rs: 'False'
    sync_thrsh: '4'
    sync_word: '[0x1A, 0xCF, 0xFC, 0x1D]'
    var_len: 'False'
    whitening: satnogs.whitening.make_ccsds(True)
  states: {}
- name: analog_frequency_modulator_fc_0
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: (math.pi*modulation_index) / sps_tx - (((math.pi*modulation_index) / sps_tx) * 0.1)
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: (2*math.pi*baudrate)/(sps_rx * baudrate)
  states: {state: disabled}
- name: baudrate
  id: parameter
  parameters:
    type: eng_float
    value: 50e3
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: '80'
    type: byte
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_message_debug_0_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    bus_structure_source: '[[0],]'
    type: byte
  states: {}
- name: blocks_packed_to_unpacked_xx_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_stream_mux_0
  id: blocks_stream_mux
  parameters:
    lengths: (1, 1000)
    type: byte
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '80'
    type: byte
  states: {}
- name: blocks_tagged_stream_align_0
  id: blocks_tagged_stream_align
  parameters:
    lengthtagname: packet_len
    type: complex
  states: {}
- name: blocks_tagged_stream_multiply_length_0_0
  id: blocks_tagged_stream_multiply_length
  parameters:
    c: (samp_rate/(baudrate*sps_tx))
    lengthtagname: packet_len
    type: complex
  states: {}
- name: blocks_tagged_stream_multiply_length_0_0_0
  id: blocks_tagged_stream_multiply_length
  parameters:
    c: '(sps_tx * 8) '
    comment: Length tag should be fixed for the burst tagger to work properly
    lengthtagname: packet_len
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: '1000'
    type: byte
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: '[0,0,0,0,0,0,0,1]'
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {state: disabled}
- name: digital_burst_shaper_xx_0
  id: digital_burst_shaper_xx
  parameters:
    insert_phasing: 'False'
    length_tag_name: '"packet_len"'
    post_padding: '400'
    pre_padding: '200'
    type: complex
    window: ([])
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: float
    symbol_table: '[-1, 1]'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: 1/math.sqrt(2)
    loop_bw: 2*math.pi/200
    max_dev: '0.1'
    nfilters: '128'
    osps: '1'
    resamp_type: digital.IR_PFB_NO_MF
    sps: sps_rx
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: ff
  states: {state: disabled}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    interp: sps_tx
    taps: interp_taps
    type: fff
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    ant0: TX1
    args: '"bladerf"'
    bb_gain0: '20'
    bw0: 300e3
    freq0: 401e6
    gain0: '20'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    ant0: RX1
    args: '"bladerf"'
    bb_gain0: '20'
    freq0: 401e6
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: 2e6
    sync: sync
    type: fc32
  states: {state: disabled}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pfb_arb_resampler_xxx_0
  id: pfb_arb_resampler_xxx
  parameters:
    atten: '100'
    nfilts: '32'
    rrate: ' (sps_rx * baudrate)/samp_rate'
    type: ccf
  states: {state: disabled}
- name: pfb_arb_resampler_xxx_0_0_0
  id: pfb_arb_resampler_xxx
  parameters:
    atten: '100'
    nfilts: '32'
    rrate: samp_rate/(baudrate*sps_tx)
    type: ccf
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: 401e6
    fftsize: '1024'
    type: complex
  states: {}
- name: rx_freq
  id: parameter
  parameters:
    type: eng_float
    value: 435e6
  states: {}
- name: rx_gain
  id: parameter
  parameters:
    type: eng_float
    value: '30.0'
  states: {}
- name: samp_rate_0
  id: parameter
  parameters:
    type: eng_float
    value: 2e6
  states: {}
- name: satnogs_crc_async_0
  id: satnogs_crc_async
  parameters:
    check: 'False'
    comment: |-
      This block adds some extra bytes at the 
      end of the frame that have no actual
      contribution to the original frame. They act
      as a trailing burst shaping. We have identified that
      there is a problem at the last byte received by the
      SatNOGS-COMMS and it is related to this TX chain.
      Burst shaper seems that does not solve the issue
      so probably the problem is earlier at the TX chain.
    custom_crc: satnogs.crc.crc16(0x1021, 0xFFFF, 0xFFFF, True, True)
    nbo: 'False'
    type: CRC16_CMS
  states: {state: disabled}
- name: satnogs_frame_decoder_0
  id: satnogs_frame_decoder
  parameters:
    decoder_object: variable_ieee802_15_4_variant_decoder_0
    itype: byte
    vlen: '1'
  states: {state: disabled}
- name: satnogs_frame_encoder_0
  id: satnogs_frame_encoder
  parameters:
    encoder_object: variable_ieee802_15_4_encoder_0
  states: {}
- name: sps_rx
  id: parameter
  parameters:
    type: intx
    value: '4'
  states: {}
- name: sps_tx
  id: parameter
  parameters:
    type: intx
    value: '16'
  states: {}
- name: zeromq_pub_msg_sink_1
  id: zeromq_pub_msg_sink
  parameters:
    address: zmq_pub_uri
    timeout: '100'
  states: {state: disabled}
- name: zmq_pub_uri
  id: parameter
  parameters:
    comment: URI of the ZMQ PUB, broadcasting received frames
    type: str
    value: tcp://127.0.0.1:55000
  states: {}

connections:
- [analog_frequency_modulator_fc_0, '0', blocks_tagged_stream_multiply_length_0_0_0, '0']
- [analog_quadrature_demod_cf_0, '0', digital_symbol_sync_xx_0, '0']
- [blocks_head_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_null_source_0, '0', blocks_throttle2_0, '0']
- [blocks_packed_to_unpacked_xx_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [blocks_stream_mux_0, '0', pdu_tagged_stream_to_pdu_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', blocks_stream_mux_0, '0']
- [blocks_tagged_stream_align_0, '0', osmosdr_sink_0, '0']
- [blocks_tagged_stream_align_0, '0', qtgui_freq_sink_x_0_0, '0']
- [blocks_tagged_stream_multiply_length_0_0, '0', blocks_tagged_stream_align_0, '0']
- [blocks_tagged_stream_multiply_length_0_0_0, '0', digital_burst_shaper_xx_0, '0']
- [blocks_throttle2_0, '0', blocks_stream_mux_0, '1']
- [blocks_vector_source_x_0, '0', blocks_head_0, '0']
- [digital_binary_slicer_fb_0, '0', satnogs_frame_decoder_0, '0']
- [digital_burst_shaper_xx_0, '0', pfb_arb_resampler_xxx_0_0_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', interp_fir_filter_xxx_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_binary_slicer_fb_0, '0']
- [interp_fir_filter_xxx_0, '0', analog_frequency_modulator_fc_0, '0']
- [osmosdr_source_0, '0', pfb_arb_resampler_xxx_0, '0']
- [osmosdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [pdu_pdu_to_tagged_stream_0, '0', blocks_packed_to_unpacked_xx_0, '0']
- [pdu_tagged_stream_to_pdu_0, pdus, satnogs_frame_encoder_0, pdu]
- [pfb_arb_resampler_xxx_0, '0', analog_quadrature_demod_cf_0, '0']
- [pfb_arb_resampler_xxx_0_0_0, '0', blocks_tagged_stream_multiply_length_0_0, '0']
- [satnogs_crc_async_0, out, pdu_pdu_to_tagged_stream_0, pdus]
- [satnogs_frame_decoder_0, out, blocks_message_debug_0, print]
- [satnogs_frame_decoder_0, out, zeromq_pub_msg_sink_1, in]
- [satnogs_frame_encoder_0, pdu, blocks_message_debug_0_0, log]
- [satnogs_frame_encoder_0, pdu, blocks_message_debug_0_0, print]
- [satnogs_frame_encoder_0, pdu, pdu_pdu_to_tagged_stream_0, pdus]
- [satnogs_frame_encoder_0, pdu, satnogs_crc_async_0, in]

metadata:
  file_format: 1
  grc_version: 3.10.11.0
