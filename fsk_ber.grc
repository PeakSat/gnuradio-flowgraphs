options:
  parameters:
    generate_options: qt_gui
    id: fsk_ber
    output_language: python
    title: SatNOGS-COMMS FSK BER test
  states: {}

blocks:
- name: deviation
  id: variable
  parameters:
    comment: The FSK frequency deviation
    value: 25e3
  states: {}
- name: gaussian_taps
  id: variable
  parameters:
    value: filter.firdes.gaussian(1.0, sps_tx, 1.0, 4*sps_tx)
  states: {}
- name: interp_taps
  id: variable
  parameters:
    value: numpy.convolve(numpy.array(gaussian_taps), numpy.array(sq_wave))
  states: {}
- name: modulation_index
  id: variable
  parameters:
    value: deviation / (baudrate / 2.0)
  states: {}
- name: sq_wave
  id: variable
  parameters:
    value: (1.0, ) * sps_tx
  states: {}
- name: variable_ieee802_15_4_encoder_0
  id: variable_ieee802_15_4_encoder
  parameters:
    crc_type: CRC32_C
    custom_crc: satnogs.crc.crc16(0x1021, 0xFFFF, 0xFFFF, True, True)
    preamble: '0b01010101'
    preamble_len: '16'
    rs: 'False'
    sync_word: '[0x1A, 0xCF, 0xFC, 0x1D]'
    var_len: 'False'
    whitening: satnogs.whitening.make_none()
  states: {}
- name: variable_ieee802_15_4_variant_decoder_0
  id: variable_ieee802_15_4_variant_decoder
  parameters:
    crc_type: CRC32_C
    custom_crc: satnogs.crc.crc16(0x1021, 0xFFFF, 0xFFFF, True, True)
    drop_invalid: 'True'
    frame_len: 448-4
    preamble: '[0b01010101]*12'
    preamble_thrsh: '0'
    rs: 'False'
    sync_thrsh: '4'
    sync_word: '[0x1A, 0xCF, 0xFC, 0x1D]'
    var_len: 'False'
    whitening: satnogs.whitening.make_ccsds(True)
  states: {}
- name: analog_frequency_modulator_fc_0
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: (math.pi*modulation_index) / sps_tx - (((math.pi*modulation_index) / sps_tx) * 0.1)
  states: {}
- name: baudrate
  id: parameter
  parameters:
    type: eng_float
    value: 50e3
  states: {}
- name: blocks_and_const_xx_0
  id: blocks_and_const_xx
  parameters:
    const: '0'
    type: byte
  states: {}
- name: blocks_message_debug_0_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.cons(pmt.PMT_NIL,pmt.intern("TEST"))
    period: delay_ms
  states: {}
- name: blocks_packed_to_unpacked_xx_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_tagged_stream_align_0
  id: blocks_tagged_stream_align
  parameters:
    lengthtagname: packet_len
    type: complex
  states: {}
- name: blocks_tagged_stream_multiply_length_0_0
  id: blocks_tagged_stream_multiply_length
  parameters:
    c: (samp_rate/(baudrate*sps_tx))
    lengthtagname: packet_len
    type: complex
  states: {}
- name: blocks_tagged_stream_multiply_length_0_0_0
  id: blocks_tagged_stream_multiply_length
  parameters:
    c: '(sps_tx * 8) '
    comment: Length tag should be fixed for the burst tagger to work properly
    lengthtagname: packet_len
    type: complex
  states: {}
- name: delay_ms
  id: parameter
  parameters:
    type: intx
    value: '100'
  states: {}
- name: digital_burst_shaper_xx_0
  id: digital_burst_shaper_xx
  parameters:
    insert_phasing: 'False'
    length_tag_name: '"packet_len"'
    post_padding: '400'
    pre_padding: '200'
    type: complex
    window: ([])
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: float
    symbol_table: '[-1, 1]'
  states: {}
- name: frame_size
  id: parameter
  parameters:
    label: The payload frame size
    type: intx
    value: '252'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    interp: sps_tx
    taps: interp_taps
    type: fff
  states: {}
- name: nframes
  id: parameter
  parameters:
    label: The number of frames to send
    type: intx
    value: '1000'
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pfb_arb_resampler_xxx_0_0_0
  id: pfb_arb_resampler_xxx
  parameters:
    atten: '100'
    nfilts: '32'
    rrate: samp_rate/(baudrate*sps_tx)
    type: ccf
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    ctrlpanel: 'True'
    fc: tx_freq
    fftsize: '8192'
    grid: 'True'
    name: '"TX"'
    type: complex
    update_time: '0.01'
    ymax: '0'
    ymin: '-120'
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    type: eng_float
    value: 2e6
  states: {}
- name: satnogs_ber_calculator_0
  id: satnogs_ber_calculator
  parameters:
    frame_size: frame_size
    nframes: nframes
    skip: '0'
  states: {}
- name: satnogs_crc_async_0
  id: satnogs_crc_async
  parameters:
    check: 'False'
    comment: |-
      This block adds some extra bytes at the 
      end of the frame that have no actual
      contribution to the original frame. They act
      as a trailing burst shaping. We have identified that
      there is a problem at the last byte received by the
      SatNOGS-COMMS and it is related to this TX chain.
      Burst shaper seems that does not solve the issue
      so probably the problem is earlier at the TX chain.
    custom_crc: satnogs.crc.crc16(0x1021, 0xFFFF, 0xFFFF, True, True)
    nbo: 'False'
    type: CRC32_C
  states: {}
- name: satnogs_frame_decoder_0_0
  id: satnogs_frame_decoder
  parameters:
    decoder_object: variable_ieee802_15_4_variant_decoder_0
    itype: byte
    vlen: '1'
  states: {}
- name: satnogs_frame_encoder_0
  id: satnogs_frame_encoder
  parameters:
    encoder_object: variable_ieee802_15_4_encoder_0
  states: {}
- name: soapy_bladerf_sink_0
  id: soapy_bladerf_sink
  parameters:
    center_freq: freq
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}
- name: sps_tx
  id: parameter
  parameters:
    type: intx
    value: '16'
  states: {}
- name: tx_freq
  id: parameter
  parameters:
    type: eng_float
    value: 435e6
  states: {}
- name: tx_gain
  id: parameter
  parameters:
    type: eng_float
    value: '60.0'
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: tx_freq
    gain0: tx_gain
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: dummy
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: dummy
  states: {}

connections:
- [analog_frequency_modulator_fc_0, '0', blocks_tagged_stream_multiply_length_0_0_0, '0']
- [blocks_and_const_xx_0, '0', satnogs_frame_decoder_0_0, '0']
- [blocks_message_strobe_0, strobe, satnogs_ber_calculator_0, trigger]
- [blocks_packed_to_unpacked_xx_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [blocks_packed_to_unpacked_xx_0, '0', virtual_sink_0, '0']
- [blocks_tagged_stream_align_0, '0', qtgui_freq_sink_x_0_0, '0']
- [blocks_tagged_stream_align_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_tagged_stream_align_0, '0', uhd_usrp_sink_0, '0']
- [blocks_tagged_stream_multiply_length_0_0, '0', blocks_tagged_stream_align_0, '0']
- [blocks_tagged_stream_multiply_length_0_0_0, '0', digital_burst_shaper_xx_0, '0']
- [digital_burst_shaper_xx_0, '0', pfb_arb_resampler_xxx_0_0_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', interp_fir_filter_xxx_0, '0']
- [interp_fir_filter_xxx_0, '0', analog_frequency_modulator_fc_0, '0']
- [pdu_pdu_to_tagged_stream_0, '0', blocks_packed_to_unpacked_xx_0, '0']
- [pfb_arb_resampler_xxx_0_0_0, '0', blocks_tagged_stream_multiply_length_0_0, '0']
- [satnogs_ber_calculator_0, pdu, satnogs_frame_encoder_0, pdu]
- [satnogs_crc_async_0, out, pdu_pdu_to_tagged_stream_0, pdus]
- [satnogs_frame_decoder_0_0, out, satnogs_ber_calculator_0, received]
- [satnogs_frame_encoder_0, pdu, blocks_message_debug_0_0, print]
- [satnogs_frame_encoder_0, pdu, satnogs_crc_async_0, in]
- [virtual_source_0, '0', blocks_and_const_xx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
